Commit message: version 1.0

File: final/tb3_bringup/bringup/urdf/turtlebot3_waffle.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle, 13 links, 12 joints
Joints:
- joint wheel_left_joint: type continuous -> fixed
- joint wheel_right_joint: type continuous -> fixed
